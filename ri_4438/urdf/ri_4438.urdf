Commit message: 更新xml，urdf身体简化为长方体

File: ri_4438/urdf/ri_4438.urdf (robot description, URDF)
Before this commit: robot ri_4438, 17 links, 16 joints
Links:
- link base_link: geometry collision box size=0.20 0.13 0.09; visual mesh filename=../meshes/base_link.STL
